# Keil uVision project UV-led.uvprojx, settings and files
target uv_led (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UV-led
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\core;..\lib\inc;..\program\app;..\program\bsp;..\program\intr;..\program\mid
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../core/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group app
    ../program/app/: main.c
  group mid
    ../program/mid/: mid_ad.c UartCtrl.c mid_flash.c PWMCtrl.c mid_out.c
  group bsp
    ../program/bsp/: bsp_init.c bsp_in.c
  group intr
    ../program/intr/: stm32f10x_it.c
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
