# IAR project K-BMTH-C2000-S1.0.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: LIB\inc; ; Project\UserCode; Project\Interrupt; Project\Hardware; Project\Modules; Project
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: MTHYS-C2000-V1.0.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: MTZS-C1006-V01.out
  group (top)
    Project/UserCode/: main.c
  group CONTROL
    Project/Modules/: adSample.c BT3153.c display.c eepromCtrl.c heatCtrl.c key.c MotorDriver.c
  group HARDWARE
    Project/Hardware/: DRIVER.c EEPROM.c HT1621.c
  group Interrupt
    Project/Interrupt/: stm8s_it.c
  group LIB
    LIB/src/: stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart2.c
